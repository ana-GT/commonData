Commit message: Fixed krang stuff

File: robots/Krang/urdf/Krang.urdf (robot description, URDF)
Before this commit: robot Krang, 27 links, 26 joints
Joints:
- joint JWaist: limit lower=0 upper=2.7 effort=1000 velocity=0.1 -> lower=0 upper=2.88 effort=1000 velocity=0.1
