Commit message: Added cubes for experiment GM

File: urdf/sdh.urdf (robot description, URDF)
Before this commit: robot sdh, 13 links, 12 joints
Joints:
- joint sdh_palm_joint: type fixed -> floating
