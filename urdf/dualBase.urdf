Commit message: Added new objects

File: urdf/dualBase.urdf (robot description, URDF)
Before this commit: robot lwa4d, 2 links, 1 joints
Links:
- link L0_link: geometry collision cylinder length=0.9 radius=0.1; visual cylinder length=1.2 radius=0.06
