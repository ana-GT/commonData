Commit message: Added changes of this week

File: urdf/robots/sdh.urdf (robot description, URDF)
Before this commit: robot sdh, 13 links, 12 joints
Joints:
- joint palm_joint: type fixed -> floating
